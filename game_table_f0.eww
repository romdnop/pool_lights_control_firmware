<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\game_table_f0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


